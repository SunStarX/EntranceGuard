# Keil uVision project sunstar.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: sunstar +hex
  c flags: Optim=1 oTime=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\User\led;..\User\key;..\User\rcc;..\User\exti;..\User\systick;..\User\usart;..\User\DMA;..\HARDWARE\RC522;..\HARDWARE\flash;..\HARDWARE\lcd;..\HARDWARE\font;..\HARDWARE\Beep;..\HARDWARE\as608;..\HARDWARE\led;..\HARDWARE\i2c;..\User\main;..\Module\Module_Time\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: system_stm32f10x.c core_cm3.c
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../User/: stm32f10x_it.c
    ../User/key/: bsp.key.c
    ../User/rcc/: rccclkconfig.c
    ../User/exti/: bsp_exti.c
    ../User/systick/: bsp_systick.c
    ../User/DMA/: bsp_dma_mtm.c
    ../User/usart/: rx_data_queue.c bsp_usart.c
    ../User/main/: main.c
  group Doc
    ../Doc/: readme.txt
  group HARDWARE
    ../HARDWARE/flash/: bsp_spi_flash.c
    ../HARDWARE/font/: fonts.c
    ../HARDWARE/lcd/: bsp_ili9341_lcd.c
    ../HARDWARE/RC522/: rc522_config.c rc522_function.c
    ../HARDWARE/Beep/: bsp_Beep.c
    ../HARDWARE/as608/: as608_test.c bsp_as608.c
    ../HARDWARE/led/: bsp_led.c
    ../HARDWARE/i2c/: bsp_i2c_ee.c bsp_i2c_gpio.c
  group Module
    ../Module/Module_Time/: TimeSoft.c
